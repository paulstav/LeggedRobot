# IAR project imu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; UART_BUFFERED; ENABLE_ETHERNET; ENABLE_IMU; ENABLE_FORCE; ENABLE_MOTOR; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.PreInclude: C:\ti\TivaWare_C_Series-2.1.0.12573\examples\boards\ek-tm4c1294xl\imu\main.h
  ICCARM.CCIncludePath2: ..; .; ..\..\..\..; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..\..; ..\..\..\..\third_party\lwip-1.4.1\apps; ..\..\..\..\third_party\lwip-1.4.1\ports\tiva-tm4c129\include; ..\..\..\..\third_party\lwip-1.4.1\src\include; ..\..\..\..\third_party\lwip-1.4.1\src\include\ipv4; ..\..\..\..\third_party
  OBJCOPY.OOCOutputFile: imu.bin
  ILINK.IlinkOutputFile: imu.out
  ILINK.IlinkIcfFile: imu.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Leg (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; UART_BUFFERED; ENABLE_MOTOR; ENABLE_ETHERNET; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
configuration IMU (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; UART_BUFFERED; ENABLE_UART; ENABLE_IMU; ENABLE_ETHERNET; BOARD_IMU; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
configuration FORCE (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; UART_BUFFERED; ENABLE_UART; ENABLE_FORCE; PART_TM4C1294NCPDT; TARGET_IS_TM4C129_RA0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: ADIS16375.c ADIS16375.h ForceSensor.c ForceSensor.h lwipopts.h main.c main.h spi.c spi.h startup_ewarm.c
    ../../../../utils/: lwiplib.c uartstdio.c ustdlib.c
    ../drivers/: pinout.c
